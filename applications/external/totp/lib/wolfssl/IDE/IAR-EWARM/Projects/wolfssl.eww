<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\benchmark\wolfCrypt-benchmark.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test\wolfCrypt-test.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lib\wolfSSL-Lib.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All Examples</name>
      <member>
        <project>driverlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usblib</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_cbc_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_cbc_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_ccm_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_ccm_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_cmac</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_ecb_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_ecb_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_gcm_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>aes128_gcm_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bitband</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>blinky</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_uart</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>boot_demo_usb</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>calibrate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>crc32</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_io</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_lwip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>enet_uip</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fontview</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio_jtag</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>grlib_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hello_widget</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>hibernate</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>interrupts</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>lang_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mpu_fault</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>qs_weather</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>scribble</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sd_card</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sha1_hash</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>sha1_hmac</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>synth</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tamper</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tdes_cbc_decrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tdes_cbc_encrypt</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>timers</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart_echo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>udma_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_bulk</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_keyboard</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_dev_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_hub</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_host_msc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_otg_mouse</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_demo</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_stick_update</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>watchdog</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


