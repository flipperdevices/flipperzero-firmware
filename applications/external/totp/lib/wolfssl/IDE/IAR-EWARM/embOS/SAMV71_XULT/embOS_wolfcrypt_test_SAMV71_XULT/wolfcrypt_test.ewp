# IAR project wolfcrypt_test.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG=1; __SAMV71Q21__; WOLFSSL_USER_SETTINGS
  ICCARM.CCIncludePath2: ..\..\extract_trial_here\Start\Inc; ..\..\extract_trial_here\Start\BoardSupport\Atmel\SAMV71_XPlainedUltra\DeviceSupport; ..\..\extract_trial_here\Start\BoardSupport\Atmel\SAMV71_XPlainedUltra\Setup; ..\..\..\..\..\; ..\embOS_SAMV71_XULT_user_settings
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wolfcrypt_test.srec
  ILINK.IlinkOutputFile: wolfcrypt_test.out
  ILINK.IlinkIcfFile: ..\embOS_SAMV71_XULT_Linker_Script\samv71q21_wolfssl.icf
  ILINK.IlinkAdditionalLibs: ..\embOS_wolfcrypt_lib_SAMV71_XULT\Debug\Bin\wolfcrypt_lib.a; ..\..\extract_trial_here\Start\Lib\os7m_tlv_dp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    Application/: runWolfcryptTests.c
  group Device_Support
    ../../extract_trial_here/Start/BoardSupport/Atmel/SAMV71_XPlainedUltra/DeviceSupport/: startup_sam.c system_sam.c
  group Setup
    ../../extract_trial_here/Start/BoardSupport/Atmel/SAMV71_XPlainedUltra/Setup/: BSP.c HardFaultHandler.S JLINKMEM_Process.c OS_Error.c RTOSInit_SAMV71_CMSIS.c SEGGER_HardFaultHandler.c SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Config_embOS.c SEGGER_SYSVIEW_embOS.c xmtx.c xmtx2.c
  group wolfcrypt_test
    ../../../../../wolfcrypt/test/: test.c
