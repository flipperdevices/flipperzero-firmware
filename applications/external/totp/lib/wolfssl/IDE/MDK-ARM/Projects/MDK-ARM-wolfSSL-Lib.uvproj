# Keil uVision project MDK-ARM-wolfSSL-Lib.uvproj, settings and files
target MDK-RTX-TCP-FS-Lib (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: wolfSSL (library)
  c flags: Optim=4
  c define: HAVE_CONFIG_H WOLFSSL_STM32F2xx __DBG_ITM __RTX MDK_CONF_RTX_TCP_FS
  c include: ..\MDK-ARM\wolfSSL;..\..\..\; .\; C:\Keil_v5\ARM\RV31\INC
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Crypt
    ../MDK-ARM/wolfSSL/: config-FS.h
    ../../../wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_operations.c ge_operations.c hmac.c integer.c logging.c md2.c md4.c md5.c memory.c pkcs7.c poly1305.c pwdbased.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c tfm.c wc_port.c fe_low_mem.c ge_low_mem.c hash.c kdf.c misc.c srp.c wc_encrypt.c
  group SSL
    ../../../src/: crl.c internal.c wolfio.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group Config
    ./: Readme.txt
    ../MDK-ARM/wolfSSL/: config-BARE-METAL.h config-RTX-TCP-FS.h config-WOLFLIB.h
target MDK-FS-Lib (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: wolfSSL (library)
  c flags: Optim=1
  c define: HAVE_CONFIG_H  CYASSL_STM32F2xx __DBG_ITM MDK_CONF_FS
  c include: ..\MDK-ARM\wolfSSL;..\MDK-ARM\inc;..\..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
target wolfSSL-Lib (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: as above
  output: wolfSSL (library)
  c flags: Optim=4
  c define: HAVE_CONFIG_H   MDK_WOLFLIB
  c include: ..\..\..\;.\;..\MDK-ARM\wolfSSL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
